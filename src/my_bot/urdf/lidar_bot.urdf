Commit message: Connected to main robot

File: src/my_bot/urdf/lidar_bot.urdf (robot description, URDF)
Before this commit: robot my_lidar_bot, 3 links, 2 joints
Joints:
- joint servo_mount_joint: origin xyz=0 0 0.42 rpy=0 0 0 -> xyz=0 0 0.47 rpy=0 0 0
